Commit message: added debug visualization of marker

File: src/robot_description/urdf/model.urdf (robot description, URDF)
Before this commit: robot turtlebot3_waffle_pi, 11 links, 10 joints
Joints:
- joint camera_rgb_optical_joint: origin xyz=0 0 0 rpy=1.57 -1.57 -1.57 -> xyz=0 0 0 rpy=0 0 -1.57
